options:
  parameters:
    author: Gereon Such
    description: This flowgraph illustrates gr-FDC usage
    generate_options: qt_gui
    id: FDC_example
    output_language: python
    title: FDC Frequency Domain Channelizer Example
  states: {}

blocks:
- name: blocklen
  id: variable
  parameters:
    value: 2**12
  states: {}
- name: channels
  id: variable
  parameters:
    value: '[ [0.12, 0.05], [0.22, 0.1], [-0.14, 0.12], [0,0.081] ]'
  states: {}
- name: index_probe_fct
  id: variable_function_probe
  parameters:
    block_id: index_probe
    function_name: level
    poll_rate: '2.3'
    value: '0'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: relinvovl
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: FDC_FrequencyDomainChannelizer_0
  id: FDC_FrequencyDomainChannelizer
  parameters:
    act_contr_threshold: '4'
    act_det_deactivation_delay: '1'
    act_det_maxblocks: '256'
    act_det_threshold: '10'
    activity_controlled_channels: channels
    activity_detection_segments: '[ ]'
    blocksize: blocklen
    centerfrequency: 3e6
    debug: '1'
    fileoutput: '0'
    freqmode: '0'
    fs: samp_rate
    inpveclen: '1'
    minchandist: '0.01'
    minchanflankpuffer: '0.2'
    msgoutput: '1'
    outputpath: /home/gereon/chansave/
    pow_act_deactivation_delay: '1'
    pow_act_maxblocks: '256'
    relinvovl: relinvovl
    threaded: '1'
    throughput_channels: channels
    type: '0'
    verbose: '0'
    windowtype: '0'
  states: {}
- name: FDC_WaterfallMsgTagging_0
  id: FDC_WaterfallMsgTagging
  parameters:
    blockdecimation: '1'
    blocklen: blocklen
    colorscheme: '1'
    loginput: '0'
    maxvaldb: '-20'
    minvaldb: '-45'
    relinvovl: relinvovl
    samp_rate: samp_rate
    tagmode: '0'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1.0'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_1
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_2
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: int
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: blocklen
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: index_probe_fct == 0
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: index_probe_fct == 1
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: index_probe_fct == 2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: index_probe_fct == 3
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: channels[0][0] *2*3.1415
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: channels[1][0] *2*3.1415
  states: {}
- name: blocks_rotator_cc_0_1
  id: blocks_rotator_cc
  parameters:
    phase_inc: channels[2][0] *2*3.1415
  states: {}
- name: blocks_rotator_cc_0_2
  id: blocks_rotator_cc
  parameters:
    phase_inc: channels[3][0] *2*3.1415
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 3e5
    type: complex
  states: {}
- name: blocks_throttle_0_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: 3e5
    type: int
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: int( 1.0/(channels[0][1] / 1.5) )
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: int( 1.0/(channels[1][1] / 1.5) )
  states: {}
- name: digital_constellation_modulator_0_1
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: int( 1.0/(channels[2][1] / 1.5) )
  states: {}
- name: digital_constellation_modulator_0_2
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk_const
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: int( 1.0/(channels[3][1] / 1.5) )
  states: {}
- name: index_probe
  id: blocks_probe_signal_x
  parameters:
    comment: |-
      Selector is 'deprecated'
      this is a... possible... solution to avoid it
    type: int
  states: {}

connections:
- [FDC_FrequencyDomainChannelizer_0, '0', blocks_complex_to_mag_squared_0, '0']
- [FDC_FrequencyDomainChannelizer_0, '1', blocks_null_sink_0_2, '0']
- [FDC_FrequencyDomainChannelizer_0, '2', blocks_null_sink_0, '0']
- [FDC_FrequencyDomainChannelizer_0, '3', blocks_null_sink_0_0, '0']
- [FDC_FrequencyDomainChannelizer_0, '4', blocks_null_sink_0_1, '0']
- [FDC_FrequencyDomainChannelizer_0, msgout, FDC_WaterfallMsgTagging_0, msgin]
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_0_0, '0', digital_constellation_modulator_0_0, '0']
- [analog_random_source_x_0_1, '0', digital_constellation_modulator_0_1, '0']
- [analog_random_source_x_0_2, '0', digital_constellation_modulator_0_2, '0']
- [analog_random_source_x_1, '0', blocks_throttle_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', FDC_WaterfallMsgTagging_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_2, '0', blocks_add_xx_0, '3']
- [blocks_rotator_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_rotator_cc_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_rotator_cc_0_1, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_rotator_cc_0_2, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_throttle_0_0, '0', FDC_FrequencyDomainChannelizer_0, '0']
- [blocks_throttle_0_0_0, '0', index_probe, '0']
- [digital_constellation_modulator_0, '0', blocks_rotator_cc_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_rotator_cc_0_0, '0']
- [digital_constellation_modulator_0_1, '0', blocks_rotator_cc_0_1, '0']
- [digital_constellation_modulator_0_2, '0', blocks_rotator_cc_0_2, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-91-gb554eeab
